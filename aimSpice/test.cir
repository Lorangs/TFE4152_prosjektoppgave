[aimspice]
[description]
625
1 bit REGISTER simulation

.include gpdk90nm_tt.cir
.include subcircuits.cir

***************
* INPUT NODES *
***************

*name node1 node2 type  voltage
VDD   1     0     dc    1.0V
R1	2     0     100k
D1 	3 	0 	dc	PULSE(0 1 1S 0.1S 0.4S 0.5S 2S)
DN1 	4	0 	dc	PULSE(1 0 1S 0.1S 0.4S 0.5S 2S)

*********
* SIMUL *
*********

*   input   output  writeEN     writeENneg  readEN      readENneg   powerup powerdown   type(bitcell)

* KOMMENTERT UT *
*xBC1 data    outp    we          wen         re          ren         VDD     VSS         bitcell

xTG1 1 4 3 2 1 0 transmission_gate

[dc]
1
VDD
0
1
0.1
[tran]
0.1
5
X
X
0
[ana]
4 0
[end]
