[aimspice]
[description]
262
1 bit REGISTER simulation

.include gpdk90nm_tt.cir
.include subcircuits.cir

VDD 1 0 dc 1.0V
R1 2 0 100k
*D1 3 0 PULSE(0 1 1S 0.1S 0.4S 0.5S 2S)
*DN1 4 0 PULSE(1 0 1S 0.1S 0.4S 0.5S 2S)

*xTG1 1 4 3 2 1 0 transmission_gate
xNOT 3 2 1 0 not_gate

[tran]
0.1
5
X
X
0
[ana]
4 1
0
1 1
1 1 0 5
3
v(1)
v(2)
v(3)
[end]
